# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L15XXB_128K
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\inc; ..\FreeRtos\Source\include; ..\FreeRtos\Common\include; ..\FreeRtos\Source\portable\IAR\ARM_CM3; ..\StdLib\CMSIS\Include; ..\StdLib\STM32L1xx_StdPeriph_Driver\inc; ..\StdLib\Board; ..\StdLib\CMSIS\Device\ST\STM32L1xx\Include; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FreeRtos
    ../FreeRtos/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRtos/Portable
    ../FreeRtos/Source/portable/MemMang/: heap_4.c
  group FreeRtos/Portable/IAR/ARM_CM3
    ../FreeRtos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group StdLib
    ../StdLib/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_tim.c
  group System
    ./: startup_stm32l1xx_hd.s
    ../System/: system_stm32l1xx.c
  group User
    ../src/: hw_init.c main.c stm32l1xx_dht11.c stm32l1xx_int_eeprom.c stm32l1xx_it.c stm32l1xx_lcd_ST7522.c stm32l1xx_sht11.c STM32L_low_power_tick_management.c
