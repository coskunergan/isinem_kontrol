# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_HD,RVDS_ARMCM3_LM3S102
  c include: ..\inc;..\FreeRtos\Common\include;..\FreeRtos\Source\include;..\StdLib\Board;..\StdLib\CMSIS\Device\ST\STM32L1xx\Include;..\StdLib\CMSIS\Include;..\StdLib\STM32L1xx_StdPeriph_Driver\inc;..\FreeRtos\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group System
    ../System/: system_stm32l1xx.c
    ./: startup_stm32l1xx_hd.s
  group FreeRtos
    ../FreeRtos/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRtos/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRtos/Source/portable/MemMang/: heap_4.c
    ../FreeRtos/Common/Minimal/: BlockQ.c dynamic.c blocktim.c countsem.c GenQTest.c recmutex.c PollQ.c semtest.c
  group User
    ../src/: main.c STM32L_low_power_tick_management.c stm32l1xx_it.c stm32l1xx_int_eeprom.c hw_init.c stm32l1xx_lcd_ST7522.c stm32l1xx_sht11.c stm32l1xx_dht11.c
    ../inc/: FreeRTOSConfig.h
  group StdLib
    ../StdLib/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_dbgmcu.c stm32l1xx_flash.c stm32l1xx_wwdg.c stm32l1xx_iwdg.c
software components: CMSIS:CORE 5.4.0
